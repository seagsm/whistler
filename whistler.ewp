# IAR project whistler.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: src\system\STM32F10x_StdPeriph_Driver\inc; src\system\CMSIS\CM3\DeviceSupport\ST\STM32F10x; src\board\board_GUI; src\board\Embedded_GUI_HAL; src\board\Embedded_GUI_Library; src\board\GUI; src\TouchPanel; src\GLCD; src\board; src\cpp; src\api; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: medic.srec
  ILINK.IlinkOutputFile: stm32f103cbt.out
  ILINK.IlinkIcfFile: linker\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group src
    src/: main.cpp main.h
    linker/: stm32f103xC.icf
  group src/board
    src/board/: board_dma.c board_dma.h board_gpio.c board_gpio.h board_NVIC.c board_NVIC.h board_pwm.c board_pwm.h board_r_buff.c board_r_buff.h board_sys_tick.c board_sys_tick.h board_system_type.h board_timer.c board_timer.h board_uart.c board_uart.h
  group src/board/board_gui
    src/board/board_GUI/: board_GUI_primitives.h ts_button.h
  group src/board/glcd
    src/GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h
  group src/board/GuiApi/Embedded_GUI_HAL
    src/board/Embedded_GUI_HAL/: JoyHal.c JoyHal.h LcdHal.c LcdHal.h ssd1289.c ssd1289.h stm32HAL.h touchscreen.c touchscreen.h TscHal.c TscHal.h
  group src/board/GuiApi/Embedded_GUI_Library
    src/board/Embedded_GUI_Library/: cursor.c cursor.h gl_fonts.c gl_fonts.h graphicObject.c graphicObject.h graphicObjectTypes.h images.c images.h
  group src/board/GuiApi/GUI
    src/board/GUI/: pictures.c pictures.h uiappuser.c uiappuser.h uiframework.c uiframework.h
  group src/board/touch_panel
    src/TouchPanel/: TouchPanel.c TouchPanel.h
  group src/cpp
    src/cpp/: ButtonEvents.cpp ButtonEvents.h classButton.cpp classButton.h classDraw.cpp classDraw.h classLcd.cpp classLcd.h classTouchScreen.cpp classTouchScreen.h sensor.cpp sensor.h
  group src/system/CMSIS
    src/system/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group src/system/startup
    src/system/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group src/system/StdPeriph_Driver
    src/system/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
