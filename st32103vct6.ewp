# IAR project st32103vct6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: src; src\inc; src\Board\I2S_board_driver; src\Board\board_GUI; src\GLCD; src\TouchPanel; src\WM8731; src\OV7725; src\SCCB; src\SysTick; src\StdPeriphLib\inc; src\FreeRTOS; src\FreeRTOS\Source; src\FreeRTOS\Source\include; src\FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: src\FreeRTOS; src\FreeRTOS\Source\include; src\FreeRTOS\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: st32103vct6.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: linker\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    src/: stm32f10x_conf.h WavSample.h
  group FreeRTOS
    src/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    src/FreeRTOS/Source/include/: FreeRTOSConfig.h
    src/FreeRTOS/Source/portable/MemMang/: heap_2.c
    src/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group src
    src/: main.c main.h stm32f10x_it.c sys_req.txt
  group src/Board/board_GUI
    src/Board/board_GUI/: board_GUI.c board_GUI.h board_GUI_primitives.c board_GUI_primitives.h ts_button.c ts_button.h
  group src/Board/I2S_board_driver
    src/Board/I2S_board_driver/: I2S_board_driver.c I2S_board_driver.h
  group src/CMSIS
    src/CMSIS/: core_cm3.c
    src/: system_stm32f10x.c
  group src/GLCD
    src/GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group src/SCCB
    src/SCCB/: SCCB.c SCCB.h
  group src/startup
    src/startup/: startup_stm32f10x_hd.s
  group src/StdPeriphLib
    src/StdPeriphLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group src/SysTick
    src/SysTick/: stm32f10x_systick.c systick.c
  group src/TouchPanel
    src/TouchPanel/: TouchPanel.c TouchPanel.h
  group src/WM8731
    src/WM8731/: wav.c wav.h WM8731.c WM8731.h
